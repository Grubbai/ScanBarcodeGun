# Keil uVision project STM32F10X_Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=3
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\ST_Libraries\CMSIS;..\..\User;..\..\ST_Libraries\FWlib\inc;..\..\FreeRTOS\Source\include;..\..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\Bsp;..\..\Hal;..\..\Common;..\..\Config;..\..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../../App/: startapp_main.c app_cfgDataTask.c app_factoryTestTask.c app_keyTask.c app_pairTask.c app_scannerTask.c app_zigbeeTask.c
  group Hal
    ../../Hal/: hal_init.c hal_key.c hal_timer.c hal_usart.c hal_watchdog.c hal_zigbee.c hal_PromptInfo.c
  group FreeRTOS
    ../../FreeRTOS/Source/portable/RVDS/ARM_CM3/: portmacro.h port.c
    ../../FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Bsp
    ../../Bsp/: bsp_beeper.c bsp_init.c bsp_eeprom.c bsp_key.c bsp_led.c bsp_motor.c bsp_timer.c bsp_usart.c bsp_watchdog.c
  group Config
    ../../App/: app_config.h
    ../../Config/: FreeRTOSConfig.h includes.h
  group System
    ../../Config/: stm32f10x_conf.h stm32f10x_it.c
    ../../ST_Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ../../ST_Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group STlibV3.5
    ../../ST_Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
  group Common
    ../../Common/: eeprom.c common_def.h
  group DOC
    ../../Doc/: readme.txt
software components: CMSIS:CORE 4.1.0
